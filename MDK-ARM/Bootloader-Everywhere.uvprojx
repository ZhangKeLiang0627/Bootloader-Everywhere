# Keil uVision project Bootloader-Everywhere.uvprojx, settings and files
target Bootloader-Everywhere (6160000::V6.16::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Bootloader-Everywhere +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: -Oz -fno-exceptions
  c include: ..\Bootloader;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\UserApp
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Bootloader-Everywhere/Startup
    ./: startup_stm32f401xe.s
  group Bootloader-Everywhere/Bootloader
    ../Bootloader/: bl.cpp protocol.cpp bl_port_stm32f4.cpp
  group Bootloader-Everywhere/Drivers/HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c
  group Bootloader-Everywhere/Host
    ../Core/Src/: system_stm32f4xx.c main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Bootloader-Everywhere/User
    ../UserApp/: main.cpp
software components: CMSIS:CORE 5.5.0
